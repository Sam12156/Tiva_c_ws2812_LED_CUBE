# Keil uVision project ECE_425_LED_Cube.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECE_425_7x7x7_Cube
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: SysTick_Delay.c WS2812.c GPIO.c ADC.c led_cube.c board.c patterns.c Timers.c advanced_patterns.c helper_functions.c additional_patterns.c common_functions.c pattern_functions.c
  group inc
    ./: SysTick_Delay.h WS2812.h GPIO.h ADC.h board.h patterns.h Timers.h led_cube.h new_patterns.h common_functions.h pattern_functions.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
